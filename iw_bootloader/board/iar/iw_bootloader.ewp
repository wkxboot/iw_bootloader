# IAR project iw_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54606J512 NXP LPC54606J512
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_LPC54606J512BD100
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../../CMSIS/Include; ../../device/LPC54606; ../../device/LPC54606/drivers; ../../rtos/amazon-freertos/lib/include; ../../rtos/amazon-freertos/lib/include/private; ../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../board/bsp; ../../board/user; ../../board/user/serial; ../../board/user/peripheral; ../../board/user/tasks; ../../board/user/debug/cpu; ../../board/user/debug/log; ../../board/user/debug/log/SEGGER_RTT_V612j/RTT; ../../board/user/rtos; ../../board/user/lib; ../../board/user/flash_if; ../../board/user/device_env; ../../board/user/crc16; ../../board/user/md5
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../board/user/rtos
  AARM.AExtraOptionsV2: --no_path_in_file_macros
  OBJCOPY.OOCOutputFile: iw_bootloader.bin
  ILINK.IlinkOutputFile: iw_bootloader.out
  ILINK.IlinkIcfFile: iw_bootloader.icf
  ILINK.IlinkAdditionalLibs: ../../device/LPC54606/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group board/bsp
    ../bsp/: board.c clock_config.c pin_mux.c
  group board/user/bootloader
    ../user/bootloader/: bootloader.c
  group board/user/crc16
    ../user/crc16/: crc16.c
  group board/user/debug/cpu
    ../user/debug/cpu/: cpu_utils.c
  group board/user/debug/log
    ../user/debug/log/: log.c
  group board/user/debug/log/segger_rtt
    ../user/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../user/debug/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group board/user/device_env
    ../user/device_env/: device_env.c
  group board/user/flash_if
    ../user/flash_if/: flash_if.c
  group board/user/md5
    ../user/md5/: md5.c
  group board/user/rtos
    ../user/rtos/: cmsis_os.c freertos.c main.c
  group board/user/tasks
    ../user/tasks/: debug_task.c tasks_init.c
  group board/user/lib
    ../user/lib/: utils.c
  group device
    ./: startup_LPC54606.s
    ../../device/LPC54606/: system_LPC54606.c
  group device/hal_driver
    ../../device/LPC54606/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
  group rtos/port
    ../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: fsl_tickless_systick.c port.c portasm.s
    ../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_4.c
  group rtos/src
    ../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
